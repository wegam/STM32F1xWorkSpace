# Keil uVision project STM32F1xUSB.uvprojx, settings and files
target Audio_Speaker (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Audio_Speaker +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Audio_Speaker\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./main/: main.c STM32_IT.c STM32_WOW.C
  group Lib/STM32F10x
    ../../Library/STM32F10x_StdPeriph_Driver/SCR/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Lib/USB
    ../../Library/USB/SCR/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Lib/Startup
    ../../Library/Startup/STM32F10x/: cortexm3_macro.s stm32f10x_vector.s
  group Document
    ../../Document/: C语言printf()输出格式大全.txt note.txt readme.txt USB说明.txt 常用C语言标准库函数.txt 常用头文件.txt 仿真设置 .txt
  group Audio_Speaker
    ../../Examples/USB/Audio_Speaker/source/: Audio_Speaker.c hw_config.c i2s_codec.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Audio_Speaker_WOW
    ../../Examples/USB/Audio_Speaker_WOW/source/: Audio_Speaker.c hw_config.c i2s_codec.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Custom_HID
    ../../Examples/USB/Custom_HID/source/: Custom_HID.c hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Device_Firmware_Upgrade
    ../../Examples/USB/Device_Firmware_Upgrade/source/: usb_pwr.c usb_prop.c usb_istr.c usb_desc.c stm32f10x_it.c spi_if.c spi_flash.c nor_if.c main.c hw_config.c fsmc_nor.c flash_if.c dfu_mal.c Device_Firmware_Upgrade.c
  group JoyStickMouse
    ../../Examples/USB/JoyStickMouse/source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c
  group Mass_Storage
    ../../Examples/USB/Mass_Storage/source/: fsmc_nand.c hw_config.c main.c mass_mal.c memory.c msd.c nand_if.c scsi_data.c sdcard.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c usb_sil.c
  group Virtual_COM_Port
    ../../Examples/USB/Virtual_COM_Port/source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c Virtual_COM_Port.c
  group Virtual_COM_Port_IAD
    ../../Examples/USB/Virtual_COM_Port_IAD/source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c Virtual_COM_Port.c Virtual_COM_Port_IAD.c
  group Driver/WOW
    ../../Driver/WOW/SCR/: _STM32_TOOLS.C STM32_096OLED.C STM32_A3987.C STM32_ADC.C STM32_CAN.C STM32_CRC.C STM32_DAC.C STM32_DMA.C STM32_EXTI.C STM32_FLASH.C STM32_GPIO.C STM32_I2C.C STM32_NVIC.C STM32_PWM.C STM32_RCC.C STM32_RTC.C STM32_SDCard.C STM32_SPI.C STM32_SPI_Struct.C STM32_SYS.C STM32_SYSLED.C STM32_SYSTICK.C STM32_TIM.C STM32_USART.C STM32_WDG.C
  group Driver/Tool
    ../../Driver/Tool/: BMP.C CRC.C LinkedList.C TOOL.C
target Audio_Speaker_WOW (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Audio_Speaker_WOW +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Audio_Speaker_WOW\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Custom_HID (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Custom_HID +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Custom_HID\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Device_Firmware_Upgrade (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Device_Firmware_Upgrade +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Device_Firmware_Upgrade\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target JoyStickMouse (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: JoyStickMouse +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\JoyStickMouse\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Mass_Storage (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: JoyStickMouse +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Mass_Storage\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Virtual_COM_Port (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Virtual_COM_Port +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Virtual_COM_Port\include;..\..\Driver\WOW\INC;..\..\Driver\Tool;.\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target Virtual_COM_Port_IAD (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: Virtual_COM_Port_IAD +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\..\Library\STM32F10x_StdPeriph_Driver\INC;..\..\Library\Startup\STM32F10x;..\..\Library\C;..\..\Library\ARM\Include;..\..\Library\USB\INC;..\..\Examples\USB\Virtual_COM_Port_IAD\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
